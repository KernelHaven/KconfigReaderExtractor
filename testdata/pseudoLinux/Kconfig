## testdata/pseudoLinux/Kconfig
```kconfig
config A
	bool "Variable A"

config B
    bool "Variable B"
    depends on A

config C
    tristate "A tristate"
```
